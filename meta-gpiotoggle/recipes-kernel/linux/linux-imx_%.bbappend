FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://devtool-fragment.cfg file://0001-Adding-Led-and-Button-to-Device-Tree-and-using-both.patch"

