FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://devtool-fragment.cfg file://0001-Disabled-Uart3-and-Enable-INPUT-in-GPIO5-8.patch"

