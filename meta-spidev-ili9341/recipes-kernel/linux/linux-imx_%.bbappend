FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://devtool-fragment.cfg file://0001-Spidev-and-ECSPI2-added-for-ILI9341.patch"

